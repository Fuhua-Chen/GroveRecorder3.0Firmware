# Keil uVision project NuOneExEnc.uvproj, settings and files
target NuOneExEnc (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ISD9160 Nuvoton
  cpu: IRAM(0x20000000-0x20002FFF) IROM(0-0x233FF) CLOCK(49152000) CPUTYPE("Cortex-M0")
  output: Recorder3 +hex
  AfterMake: fromelf --bincombined --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: __ISD9100__
  c include: .;..\..\..\..\Library\Device\Nuvoton\ISD9100\Include;..\..\..\..\Library\Framework\inc;..\..\..\..\Library\IO\inc;..\..\..\..\Library\Audio\inc;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Storage\inc;..\..\..\..\Library\CMSIS\Include;..\
  asm define: __ISD9100__
  memory RVCT4: ROM 0x0 size 0x23400
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\Application_Keil.ld
  link misc: --pd="-DSRAM_SIZE=0x3000" --pd="-DROM_SIZE=0x23400"  --map --datacompressor=off --info=inline --entry Reset_Handler --remove
  group Source
    ../: Readme.txt Readme_FileInfo.txt main.c AppFunctions.c AppCallback.c InputKeyActions.c InterruptHandler.c Powerdown.c
  group Include
    ../: SPIFlashMap.h App.h ConfigApp.h ConfigSysClk.h ConfigIO.h ConfigIP.h InState.h
  group CMSIS
    ../../../../Library/Device/Nuvoton/ISD9100/Source/: system_ISD9100.c
    ./: startup_ISD9100.s
  group NuOneExApp
    ../NuOneExApp/: NuOneExApp_Decode.c NuOneExApp_Decode.h NuOneExApp_Encode.c NuOneExApp_Encode.h
  group Framework
    ../../../../Library/Framework/src/: AudioMixer.c AudioRom.c BufCtrl.c ConfigIO.c MicSpk.c Playback.c Record.c SPIFlashUtil.c SysClk.c PdmaCtrl.c
  group Storage
    ../../../../Library/Storage/src/: SPIFlash.c
  group IO
    ../../../../Library/IO/src/: Keypad.c
  group Driver
    ../../../../Library/StdDriver/src/: acmp.c adc.c biq.c bod.c capsense.c clk.c CRC.c dpwm.c fmc.c gpio.c i2c.c i2s.c pdma.c pwm.c retarget.c rtc.c spi.c sys.c talarm.c timer.c uart.c wdt.c
  group Library
    ../../../../Library/Audio/arm/: ImaAdpcm_Keil.lib LP8_Keil.lib MD4_Keil.lib MIDISynthEx_Keil.lib NuADCFilterEx_Keil.lib NuDACFilterEx_Keil.lib NuLiteEx_Keil.lib NuOneEx_Keil.lib NuSoundEx_Keil.lib NuVoxEx_Keil.lib P16_Keil.lib
